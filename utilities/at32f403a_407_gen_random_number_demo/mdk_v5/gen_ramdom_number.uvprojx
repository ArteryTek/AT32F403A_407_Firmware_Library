# Keil uVision project gen_ramdom_number.uvprojx, settings and files
target at_start_f403a (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f403a_gen_random_number +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\inc;..\..\..\project\at32f403a_407_board;..\..\..\libraries\drivers\inc;..\..\..\libraries\cmsis\cm4\device_support;..\..\..\libraries\cmsis\cm4\core_support
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c random.c main.c
  group bsp
    ../../../project/at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_rtc.c at32f403a_407_usart.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_bpr.c at32f403a_407_pwc.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group readme
    ../: readme.txt
target at_start_f407 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F407AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.0
  cpu: as above
  output: at32f407_gen_random_number +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
