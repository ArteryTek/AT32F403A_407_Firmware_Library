<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\app_led3_toggle.ewp</path>
    </project>
</workspace>
