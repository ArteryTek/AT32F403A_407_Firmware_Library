# Keil uVision project app_led4_toggle.uvprojx, settings and files
target at_start_f403a (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.1
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f403a_app_led4_toggle +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\inc;..\..\..\..\..\project\at32f403a_407_board;..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\middlewares\usbd_drivers\inc;..\..\..\..\..\middlewares\usbd_class\hid_iap
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c hid_iap_user.c main.c
  group bsp
    ../../../../../project/at32f403a_407_board/: at32f403a_407_board.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_usart.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_usb.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
    ../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group usbd_drivers
    ../../../../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group usbd_class
    ../../../../../middlewares/usbd_class/hid_iap/: hid_iap_class.c hid_iap_desc.c
  group readme
    ../: readme.txt
target at_start_f407 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: -AT32F407VGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x38000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: at32f407_app_led4_toggle +hex
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F407VGT7,USE_STDPERIPH_DRIVER,AT_START_F407_V1
  c include: as above
  memory RVCT4: ROM 0x8004000 size 0xfc000
  memory RVCT9: RAM 0x20000000 size 0x38000
