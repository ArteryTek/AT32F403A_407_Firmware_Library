# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: -AT32F403AVGT7 ArteryTek
  cpu: IRAM(0x20000000-0x20037FFF) IROM(0x08000000-0x080FFFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Template +hex
  c flags: Optim=1
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\..\templates\inc;..\..\..\at32f403a_407_board
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group user
    ../src/: at32f403a_407_int.c at32f403a_407_clock.c main.c
  group bsp
    ../../../at32f403a_407_board/: at32f403a_407_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group firmware
    ../../../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group readme
    ../: readme.txt
