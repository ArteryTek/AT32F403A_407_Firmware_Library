# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F403AVGT7_v2 ArteryTek -AT32F403AVGT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F403AVGT7; USE_STDPERIPH_DRIVER; AT_START_F403A_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f403a_407_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group bsp
    ../../../at32f403a_407_board/: at32f403a_407_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f403a_407.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group firmware
    ../../../../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f403a_407_clock.c at32f403a_407_int.c main.c
